options:
  parameters:
    generate_options: qt_gui
    id: harr_Wavelet
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: D:\CCE\SEM_6\19CCE450(WAVELETS AND ITS APPLICATIONS\TERM_PROJECT(AUDIO DENOISING)\wav file\under.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\CCE\SEM_6\19CCE450(WAVELETS AND ITS APPLICATIONS\TERM_PROJECT(AUDIO DENOISING)\under.wav
    repeat: 'True'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: '[1/1.414,1/1.414]'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: '[-1/1.414,1/1.414]'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: '[-1/1.414,1/1.414]'
    type: fff
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: '[1/1.414,1/1.414]'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '2'
    taps: '[1/1.414,1/1.414]'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '2'
    taps: '[1/1.414,-1/1.414]'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '2'
    taps: '[1/1.414,-1/1.414]'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '2'
    taps: '[1/1.414,1/1.414]'
    type: fff
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_add_xx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_wavfile_source_0, '0', fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_sink_x_0_0_0, '0']
- [fir_filter_xxx_0, '0', interp_fir_filter_xxx_0, '0']
- [fir_filter_xxx_0_0, '0', interp_fir_filter_xxx_0_0, '0']
- [fir_filter_xxx_0_0_0, '0', interp_fir_filter_xxx_0_0_0, '0']
- [fir_filter_xxx_0_1, '0', interp_fir_filter_xxx_0_1, '0']
- [interp_fir_filter_xxx_0, '0', fir_filter_xxx_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', fir_filter_xxx_0_1, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [interp_fir_filter_xxx_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0_1, '0', blocks_add_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
